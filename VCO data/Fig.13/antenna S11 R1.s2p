!  02/10/2024  17:30:09
! Ref Plane: 0.000 mm
# MHZ S MA R  50
! Worked out from all points (one-way two-port):
!   1001 points, 10 MHz to 6 GHz, reference 50 ohm
!   highest |S21| = -72.75 dB at 1.573 GHz (marker M1); lowest = -116.9 dB at 680.9 MHz (marker M2)
!   lowest |S11| = -22.2 dB at 1.891 GHz (marker M3), VSWR 1.17, Z = 50.8 + j7.83 ohm
!   |S11| at or under -10 dB: 1.713 GHz to 2.969 GHz (1.256 GHz wide, 53.7 % of centre); 4.576 GHz to 5.042 GHz (466.7 MHz wide, 9.7 % of centre)
!   |S22| runs from -0.1 to 0.0 dB; largest |S21 - S12| = 0.00034
!   S11 on the Smith chart (normalised r, x): 10 MHz: 15, -26; 513.2 MHz: 0.09, -0.66; 1.112 GHz: 0.25, +0.51; 2.61 GHz: 0.95, +0.49; 4.341 GHz: 3.10, -0.12; 6 GHz: 0.78, +1.20
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -0.3  -85.0  -84.1  0.0
! 75.89 MHz  -0.6  -82.1  -81.4  0.0
! 513.2 MHz  -1.1  -88.1  -82.9  0.0
! 680.9 MHz  -1.2  -116.9  -83.4  0.0
! 1.01 GHz  -2.1  -96.5  -86.1  0.0
! 1.112 GHz  -3.4  -78.3  -76.5  -0.1
! 1.573 GHz  -6.2  -72.8  -84.9  0.0
! 1.741 GHz  -11.2  -78.6  -86.0  0.0
! 1.891 GHz  -22.2  -82.4  -83.8  0.0
! 2.011 GHz  -12.9  -88.4  -72.8  0.0
! 2.61 GHz  -12.3  -77.9  -79.8  -0.1
! 2.795 GHz  -14.4  -87.0  -85.1  -0.1
! 3.005 GHz  -8.9  -87.2  -85.0  -0.1
! 3.382 GHz  -3.6  -81.7  -84.2  -0.1
! 4.005 GHz  -3.5  -83.6  -91.9  -0.1
! 4.341 GHz  -5.8  -83.7  -82.6  -0.1
! 4.784 GHz  -15.2  -85.3  -82.7  0.0
! 5.006 GHz  -10.8  -86.8  -89.7  0.0
! 5.413 GHz  -5.4  -89.3  -82.7  0.0
! 5.605 GHz  -4.7  -84.4  -85.1  0.0
! 5.766 GHz  -4.7  -93.4  -75.0  -0.1
! 6 GHz  -4.9  -80.4  -80.7  -0.1
