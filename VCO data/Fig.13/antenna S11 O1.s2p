!  02/10/2024  16:56:00
! Ref Plane: 0.000 mm
# MHZ S MA R  50
! Worked out from all points (one-way two-port):
!   1001 points, 10 MHz to 6 GHz, reference 50 ohm
!   highest |S21| = -69.96 dB at 2.083 GHz (marker M1); lowest = -108.6 dB at 5.287 GHz (marker M2)
!   lowest |S11| = -32.9 dB at 5.437 GHz (marker M3), VSWR 1.05, Z = 48.2 - j1.34 ohm
!   |S11| at or under -10 dB: 1.918 GHz to 3.165 GHz (1.247 GHz wide, 49.1 % of centre); 5.143 GHz to 5.712 GHz (569.4 MHz wide, 10.5 % of centre)
!   |S22| runs from -0.1 to 0.0 dB; largest |S21 - S12| = 0.00034
!   S11 on the Smith chart (normalised r, x): 10 MHz: 2, -48; 507.2 MHz: 0.09, -0.87; 1.07 GHz: 0.12, +0.27; 1.963 GHz: 1.49, +0.40; 4.329 GHz: 0.98, +2.10; 6 GHz: 0.51, +0.77
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  0.0  -83.2  -82.7  0.0
! 507.2 MHz  -0.9  -84.6  -78.8  0.0
! 1.01 GHz  -1.8  -82.0  -83.9  0.0
! 1.07 GHz  -1.9  -81.2  -87.2  0.0
! 1.711 GHz  -5.1  -83.7  -87.6  0.0
! 1.891 GHz  -8.9  -78.8  -84.8  0.0
! 1.963 GHz  -12.0  -76.6  -74.4  0.0
! 2.011 GHz  -14.0  -74.2  -74.5  0.0
! 2.083 GHz  -13.7  -70.0  -72.6  0.0
! 2.22 GHz  -13.3  -83.3  -89.3  0.0
! 3.005 GHz  -14.1  -83.9  -90.4  -0.1
! 3.454 GHz  -4.7  -89.5  -84.6  -0.1
! 4.005 GHz  -2.5  -81.5  -81.2  -0.1
! 4.329 GHz  -2.8  -82.1  -81.0  -0.1
! 5.006 GHz  -7.2  -92.6  -88.5  0.0
! 5.287 GHz  -15.4  -108.6  -84.8  0.0
! 5.437 GHz  -32.9  -78.0  -86.1  0.0
! 5.527 GHz  -19.0  -81.3  -83.2  0.0
! 5.623 GHz  -13.1  -87.6  -80.5  0.0
! 5.832 GHz  -7.4  -82.7  -79.8  -0.1
! 5.904 GHz  -6.4  -83.9  -75.0  -0.1
! 6 GHz  -5.3  -84.9  -80.7  -0.1
