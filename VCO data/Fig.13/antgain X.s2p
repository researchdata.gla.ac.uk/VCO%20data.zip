!  09/10/2024  13:53:11
! Ref Plane: 0.000 mm
# MHZ S MA R  50
! Worked out from all points (weakly coupled two-port):
!   1001 points, 10 MHz to 6 GHz, reference 50 ohm
!   highest |S21| = -32.79 dB at 2.664 GHz (marker M1); lowest = -100.3 dB at 189.7 MHz (marker M2)
!   lowest |S11| = -27.6 dB at 2.652 GHz (marker M3), VSWR 1.09, Z = 47.9 + j3.5 ohm
!   |S11| at or under -10 dB: 2.45 GHz to 3.815 GHz (1.365 GHz wide, 43.6 % of centre); 4.027 GHz to 4.475 GHz (447.9 MHz wide, 10.5 % of centre); 4.587 GHz to 5.452 GHz (865.2 MHz wide, 17.2 % of centre) (the widest 3 of 4)
!   |S22| runs from -31.3 to 0.0 dB; largest |S21 - S12| = 0.0026
!   the Smith chart shows 1.645 GHz to 4.425 GHz only
!   S11 on the Smith chart (normalised r, x): 1.645 GHz: 1.21, -1.33; 2.005 GHz: 0.24, -0.52; 2.298 GHz: 0.39, +0.10; 2.843 GHz: 0.89, +0.35; 3.412 GHz: 0.68, +0.22; 4.425 GHz: 1.76, +0.32
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  1.4  -82.5  -87.8  0.0
! 189.7 MHz  0.5  -100.3  -84.0  -0.3
! 752.8 MHz  -1.4  -48.3  -48.7  -1.1
! 1.01 GHz  -7.4  -42.0  -42.0  -1.3
! 1.268 GHz  -7.4  -39.6  -39.4  -12.9
! 1.645 GHz  -5.7  -36.4  -36.5  -4.1
! 1.921 GHz  -6.7  -35.4  -35.5  -7.5
! 2.005 GHz  -3.3  -43.0  -43.0  -17.0
! 2.011 GHz  -3.4  -42.6  -42.6  -18.5
! 2.047 GHz  -5.5  -37.2  -37.3  -29.0
! 2.13 GHz  -8.5  -34.9  -35.0  -14.0
! 2.298 GHz  -7.0  -36.4  -36.5  -11.5
! 2.49 GHz  -11.6  -33.6  -33.7  -11.6
! 2.652 GHz  -27.6  -32.9  -33.0  -12.6
! 2.664 GHz  -26.4  -32.8  -32.9  -12.9
! 2.843 GHz  -14.5  -33.6  -33.5  -16.8
! 3.005 GHz  -16.3  -33.5  -33.2  -16.9
! 3.412 GHz  -12.9  -39.9  -39.8  -3.9
! 4.005 GHz  -9.7  -39.4  -39.7  -4.6
! 4.425 GHz  -10.5  -35.4  -35.5  -8.9
! 5.006 GHz  -11.6  -34.2  -34.9  -11.9
! 6 GHz  -13.0  -49.3  -49.1  -4.2
