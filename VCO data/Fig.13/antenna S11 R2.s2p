!  04/10/2024  16:16:33
! Ref Plane: 0.000 mm
# MHZ S MA R  50
! Worked out from all points (one-way two-port):
!   1001 points, 10 MHz to 6 GHz, reference 50 ohm
!   highest |S21| = -69.95 dB at 5.994 GHz (marker M1); lowest = -129.2 dB at 4.419 GHz (marker M2)
!   lowest |S11| = -21.8 dB at 1.987 GHz (marker M3), VSWR 1.18, Z = 50.4 + j8.21 ohm
!   |S11| at or under -10 dB: 1.836 GHz to 3.186 GHz (1.35 GHz wide, 53.8 % of centre); 4.757 GHz to 5.277 GHz (519.5 MHz wide, 10.4 % of centre)
!   |S22| runs from -0.2 to 0.0 dB; largest |S21 - S12| = 0.00033
!   S11 on the Smith chart (normalised r, x): 10 MHz: -1, -44; 537.1 MHz: 0.06, -0.79; 1.184 GHz: 0.15, +0.40; 1.993 GHz: 0.99, +0.17; 4.449 GHz: 1.95, +1.37; 6 GHz: 0.27, +0.79
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  0.0  -85.7  -82.5  0.0
! 537.1 MHz  -0.6  -82.7  -76.0  0.0
! 1.01 GHz  -1.8  -87.4  -81.0  0.0
! 1.184 GHz  -2.3  -79.3  -81.5  0.0
! 1.286 GHz  -7.0  -84.0  -83.1  -0.1
! 1.747 GHz  -7.1  -87.9  -91.0  -0.1
! 1.987 GHz  -21.8  -82.0  -74.7  -0.1
! 1.993 GHz  -21.6  -74.2  -74.6  -0.1
! 2.011 GHz  -20.5  -75.7  -71.4  -0.1
! 2.071 GHz  -16.4  -75.1  -74.2  0.0
! 2.166 GHz  -14.1  -80.3  -86.0  -0.1
! 3.005 GHz  -12.6  -84.4  -102.9  -0.1
! 3.508 GHz  -4.5  -78.2  -92.0  -0.1
! 4.005 GHz  -3.1  -83.9  -77.0  -0.1
! 4.419 GHz  -5.7  -129.2  -84.4  -0.1
! 4.449 GHz  -5.8  -82.2  -82.0  -0.1
! 5.006 GHz  -16.7  -92.5  -92.0  0.0
! 5.473 GHz  -6.6  -81.7  -75.0  0.0
! 5.766 GHz  -3.9  -90.4  -75.6  -0.2
! 5.832 GHz  -3.5  -79.1  -81.6  -0.2
! 5.994 GHz  -2.9  -70.0  -75.6  -0.2
! 6 GHz  -2.9  -82.8  -83.5  -0.2
