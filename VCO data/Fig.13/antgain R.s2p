!  09/10/2024  13:45:17
! Ref Plane: 0.000 mm
# MHZ S MA R  50
! Worked out from all points (weakly coupled two-port):
!   1001 points, 10 MHz to 6 GHz, reference 50 ohm
!   highest |S21| = -32.23 dB at 2.676 GHz (marker M1); lowest = -102.8 dB at 189.7 MHz (marker M2)
!   lowest |S11| = -27.7 dB at 2.658 GHz (marker M3), VSWR 1.09, Z = 47.8 + j3.34 ohm
!   |S11| at or under -10 dB: 2.448 GHz to 3.815 GHz (1.367 GHz wide, 43.7 % of centre); 4.028 GHz to 4.472 GHz (443.7 MHz wide, 10.4 % of centre); 4.612 GHz to 5.454 GHz (841.8 MHz wide, 16.7 % of centre) (the widest 3 of 4)
!   |S22| runs from -25.5 to 0.0 dB; largest |S21 - S12| = 0.0019
!   the Smith chart shows 1.663 GHz to 4.431 GHz only
!   S11 on the Smith chart (normalised r, x): 1.663 GHz: 1.10, -1.22; 2.005 GHz: 0.24, -0.53; 2.304 GHz: 0.39, +0.12; 2.849 GHz: 0.91, +0.36; 3.412 GHz: 0.69, +0.22; 4.431 GHz: 1.78, +0.30
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  1.4  -84.7  -88.5  0.0
! 189.7 MHz  0.5  -102.8  -81.4  -0.3
! 309.5 MHz  0.0  -80.5  -74.4  -0.3
! 698.9 MHz  -0.5  -50.0  -49.9  -1.0
! 776.7 MHz  -2.0  -57.5  -57.5  -0.7
! 860.6 MHz  -4.6  -41.2  -41.3  -1.2
! 1.01 GHz  -7.1  -41.8  -41.8  -0.8
! 1.268 GHz  -7.3  -38.0  -37.9  -14.6
! 1.663 GHz  -6.0  -35.1  -35.2  -4.6
! 2.005 GHz  -3.3  -43.1  -43.1  -13.1
! 2.011 GHz  -3.4  -42.8  -42.9  -14.0
! 2.071 GHz  -7.5  -35.4  -35.4  -24.9
! 2.304 GHz  -7.0  -36.4  -36.5  -12.1
! 2.658 GHz  -27.7  -32.4  -32.5  -15.4
! 2.676 GHz  -26.0  -32.2  -32.2  -15.8
! 2.849 GHz  -14.3  -32.6  -32.5  -14.7
! 3.005 GHz  -16.4  -33.4  -33.2  -20.9
! 3.412 GHz  -13.1  -38.5  -38.3  -4.4
! 4.005 GHz  -9.7  -36.4  -36.6  -5.0
! 4.431 GHz  -10.5  -35.0  -35.3  -9.0
! 5.006 GHz  -11.7  -36.8  -37.4  -13.6
! 6 GHz  -13.1  -56.2  -56.2  -4.8
