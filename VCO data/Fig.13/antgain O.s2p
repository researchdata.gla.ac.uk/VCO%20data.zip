!  09/10/2024  12:46:29
! Ref Plane: 0.000 mm
# MHZ S MA R  50
! Worked out from all points (weakly coupled two-port):
!   1001 points, 10 MHz to 6 GHz, reference 50 ohm
!   highest |S21| = -30.95 dB at 1.903 GHz (marker M1); lowest = -109.9 dB at 177.7 MHz (marker M2)
!   lowest |S11| = -27.2 dB at 2.652 GHz (marker M3), VSWR 1.09, Z = 48.2 + j3.9 ohm
!   |S11| at or under -10 dB: 2.449 GHz to 3.815 GHz (1.366 GHz wide, 43.6 % of centre); 4.031 GHz to 4.474 GHz (443.8 MHz wide, 10.4 % of centre); 4.591 GHz to 5.453 GHz (861.7 MHz wide, 17.2 % of centre) (the widest 3 of 4)
!   |S22| runs from -45.7 to 0.0 dB; largest |S21 - S12| = 0.0031
!   the Smith chart shows 1.759 GHz to 3.754 GHz only
!   S11 on the Smith chart (normalised r, x): 1.759 GHz: 0.85, -0.79; 2.011 GHz: 0.24, -0.48; 2.25 GHz: 0.36, -0.02; 2.598 GHz: 1.05, +0.20; 3.065 GHz: 1.09, -0.28; 3.754 GHz: 0.73, +0.43
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  1.4  -83.2  -85.7  0.0
! 177.7 MHz  0.6  -109.9  -84.3  -0.7
! 417.3 MHz  -0.1  -76.0  -77.0  -1.4
! 615 MHz  0.0  -50.8  -51.0  -1.8
! 920.5 MHz  -5.7  -39.1  -39.3  -1.7
! 1.01 GHz  -7.1  -43.5  -43.7  -1.3
! 1.166 GHz  -7.8  -41.9  -41.9  -23.7
! 1.274 GHz  -7.3  -39.6  -39.6  -2.0
! 1.759 GHz  -8.0  -34.8  -34.7  -6.4
! 1.903 GHz  -7.7  -30.9  -31.0  -20.5
! 2.011 GHz  -3.4  -39.5  -39.7  -10.9
! 2.154 GHz  -7.8  -32.7  -32.7  -12.5
! 2.25 GHz  -6.6  -35.6  -35.7  -34.4
! 2.358 GHz  -7.7  -34.8  -34.6  -12.5
! 2.598 GHz  -20.1  -31.4  -31.2  -18.2
! 2.652 GHz  -27.2  -31.2  -31.1  -22.1
! 3.005 GHz  -16.3  -35.2  -35.1  -5.5
! 3.065 GHz  -17.0  -36.4  -36.3  -4.5
! 3.754 GHz  -10.9  -37.4  -37.8  -8.6
! 4.005 GHz  -9.7  -34.8  -34.3  -18.3
! 5.006 GHz  -11.7  -38.2  -39.1  -8.1
! 6 GHz  -13.0  -57.1  -58.2  -5.2
